Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2024-01-29T00:40:05
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jan 29 00:40:05 2024 * Host: DESKTOP-13TP49N * Database: C:\Users\andre\AppData\Local\Temp\8f60cd24-d351-4d47-92a9-e92f049f2c17\4e656222-a1f7-44b8-bf61-f2d1cfc377ab\ifc * Database version: 5507 * Database creation date: Mon Jan 29 00:40:04 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jan 29 00:40:04 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jan 29 00:40:04 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcFlowController: 337MZ-11 Oras, 337MZ-11(2024):337MZ-11 Oras:160489
In: Level 1
Type - PredefinedType: FAUCET
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - InletConnectionSize: 10 mm; NominalDepth: 62.2717 mm; NominalHeight: 421.074 mm; NominalWidth: 56.721 mm
Type - Electrical - Battery: CR 2450 3 V; Bluetooth: 5.x (D060577); Operating Voltage: 3 V; Protection Class: IP 55
Type - General - Author: BIMStone; BIMObjectName: 337MZ-11(2024); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Shower mixers; NBSReference: 45-35-70/335; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 17/01/2024
Type - Green Building Properties - EAN Number: 6414150105180; EMC Directive: Radio Equipment Directive 2014/53/EU , Low Voltage Directive 2014/35/EU , EMC Directive 2014/30/EU , RoHS Directive 2011/65/EU; EN Standard: ETSI EN 301 489-1 V1.9.2 , ETSI EN 300 328 v2.2.2 , EN 61000-6-1:2007 , EN 61000-6-3:2007+A1:2011+AC:2012 , EN 60335-1:2012+A11+A13+A1+A14+A2+A15:2021, Part 19.11.4; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/337MZ-11; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL REACH: http://static.oras.com/doc/reach; URL WEEE: http://static.oras.com/WEEE/337MZ-11
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/337MZ-11; Catalog Drawing URL: http://static.oras.com/catdrw/337MZ-11; Dimension Drawing URL: http://static.oras.com/dimdrw/337MZ-11; FDV Document URL: http://www.oras.com/datasheet/337MZ-11/en/fdv; Group: Sales item; Manufacturer: Oras; Market: International;Finland; Mobile Product Information URL: http://mpi.oras.com/337MZ-11; Model: 337MZ-11 Oras; Name_en: 337MZ-11 Oras; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 337MZ-11; Product Family: null Battery-operated;Bluetooth®; Product Image URL: http://static.oras.com/image/337MZ-11; Product URL: http://static.oras.com/337MZ-11; Short Marketing: Remote bidetta set designed for Oras Healthcare Touchless faucets and remote bidetta units. including Disinfection bidetta handshower, shower hose and remote handshower wall holder; Technical DataSheet URL: http://www.oras.com/datasheet/337MZ-11/en; Type Name: 337MZ-11 Oras; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Backflow Prevention EN1717: HC; Connection Size: G1/2; Hand Shower: Remote-operated Smart Bidetta; Hand Shower Size: Ø 32 mm; Max. Hot Water Supply: 65 kg/K/s3; Max Flow Period: 2 min (1 - 1800 s); Shower Parts: Shower hose (1500 mm); Shower Spray Number: 1 shower spray; Surface treatment: White; Working Pressure: 50 - 500 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: White; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 337MZ-11(2024); Features: HandShowerSets; Finish: Polished; Grade: n/a; Material: Composite; ModelNumber: n/a; ModelReference: 337MZ-11; Name: 337MZ-11 Oras; ReplacementCost: n/a; Shape: Sculptured; Size: 170x85x200 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.0536369 m2; Volume: 0.00148728 m3
Identity Data - Mark: 64
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 337MZ-11(2024): 337MZ-11 Oras; Family and Type: 337MZ-11(2024): 337MZ-11 Oras; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 337MZ-11(2024): 337MZ-11 Oras; Type Id: 337MZ-11(2024): 337MZ-11 Oras; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
